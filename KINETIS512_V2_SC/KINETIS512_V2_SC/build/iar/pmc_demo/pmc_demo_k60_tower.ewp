# IAR project pmc_demo_k60_tower.ewp, settings and files
configuration RAM_128KB (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TWR_K60D100M
  ICCARM.CCIncludePath2: ..\..\..\src\projects\pmc_demo; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\adc16; ..\..\..\src\drivers\enet; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\platforms; ..\; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\smc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: pmc_demo_k60_tower.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\config files\128KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM_64KB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\src\projects\pmc_demo; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\adc16; ..\..\..\src\drivers\enet; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\platforms; ..\; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\smc
  ILINK.IlinkIcfFile: ..\config files\64KB_Ram.icf
configuration RAM_32KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCIncludePath2: ..\..\..\src\projects\pmc_demo; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\adc16; ..\..\..\src\drivers\enet; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\smc; ..\..\..\src\platforms; ..\
  ILINK.IlinkIcfFile: ..\config files\32KB_Ram.icf
configuration FLASH_512KB_PFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\src\projects\pmc_demo; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\adc16; ..\..\..\src\drivers\enet; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\wdog; ..\..\..\src\platforms; ..\; ..\..\..\src\drivers\rcm
  ILINK.IlinkIcfFile: ..\config files\512KB_Pflash.icf
configuration FLASH_256KB_PFLASH_256KB_DFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: ..\config files\256KB_Pflash_256KB_Dflash.icf
configuration FLASH_256KB_PFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCIncludePath2: ..\..\..\src\projects\pmc_demo; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\adc16; ..\..\..\src\drivers\enet; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\rcm; ..\..\..\src\platforms; ..\
  ILINK.IlinkIcfFile: ..\config files\256KB_Pflash.icf
configuration FLASH_128KB_PFLASH_128KB_DFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash_128KB_Dflash.icf
configuration FLASH_128KB_PFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash.icf
configuration FLASH_64KB_PFLASH_64KB_DFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: ..\config files\64KB_Pflash_64KB_Dflash.icf
  group common
    ../../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h uif.c uif.h
  group cpu
    ../../../src/cpu/: arm_cm4.c arm_cm4.h crt0.s dma_channels.h start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group cpu/headers
    ../../../src/cpu/headers/: MK60D10.h
  group drivers/adc16
    ../../../src/drivers/adc16/: adc16.c adc16.h
  group drivers/enet
    ../../../src/drivers/enet/: enet.c enet.h eth.h eth_phy.c eth_phy.h mii.c mii.h nbuf.c nbuf.h
  group drivers/llwu
    ../../../src/drivers/llwu/: llwu.c llwu.h
  group drivers/lptmr
    ../../../src/drivers/lptmr/: lptmr.c lptmr.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/pmc
    ../../../src/drivers/pmc/: pmc.c pmc.h
  group drivers/rcm
    ../../../src/drivers/rcm/: rcm.c rcm.h
  group drivers/rtc
    ../../../src/drivers/rtc/: rtc.c rtc.h
  group drivers/smc
    ../../../src/drivers/smc/: smc.c smc.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group drivers/wdog
    ../../../src/drivers/wdog/: wdog.c wdog.h
  group IAR
    ../config files/: 128KB_Pflash.icf 128KB_Pflash_128KB_Dflash.icf 128KB_Ram.icf 256KB_Pflash.icf 256KB_Pflash_256KB_Dflash.icf 32KB_Ram.icf 512KB_Pflash.icf 64KB_Pflash_64KB_Dflash.icf 64KB_Ram.icf
    ../: iar.h
  group platforms
    ../../../src/platforms/: k60_tower.h
  group project
    ../../../src/projects/pmc_demo/: isr.h low_power_demo.c
